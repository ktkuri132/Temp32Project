# Keil uVision project mdk_project_f407.uvprojx, settings and files
target f407_project (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mdk_project_f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx
  c include: ..\app;..\BSP\CMSIS\Core\Include;..\BSP\CMSIS\Core\Include\m-profile;..\BSP\stm32f4\CORE;..\BSP\stm32f4\Driver;..\Control;..\Device;..\Driver_Framework;..\Middleware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: control.c init.c main.c
  group bsp
    ../BSP/stm32f4/CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group device
    ../Device/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Device/sh1106/: fonts.c sh1106.c
    ../Device/ssd1306/: ssd1306.c
    ../Device/st7789/: st7789.c
  group driver
    ../BSP/stm32f4/Driver/: adc.c delay.c i2c_bus.c i2c_dev.c led.c misc.c nvic.c Systick.c usart.c
  group driver_framework
    ../Driver_Framework/: dev_frame.c
    ../Driver_Framework/spi/: df_spi.c
    ../Driver_Framework/lcd/: df_fonts.c df_lcd.c
    ../Driver_Framework/key/: df_key.c
    ../Driver_Framework/i2c/: df_iic.c
    ../Driver_Framework/display/: df_display.c
  group shell
    ../Middleware/shell/: shell.c
    ../Middleware/trans/: stde.c terminal_link.c
  group control
    ../Control/: filter.c pid.c
