# Keil uVision project mdk_project.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mdk_project
  group app
    ../app/: control.c main.c init.c irq.c
  group middleware
    ../Middleware/shell/: shell.c
    ../Middleware/trans/: stde.c
  group control
    ../Control/: filter.c pid.c
  group core
    ../BSP/CORE/: startup_stm32f10x_md.c syscalls.c sysmem.c stm32f10x_it.c system_stm32f10x.c
  group driver
    ../Driver/: adc.c delay.c led.c misc.c nvic.c Systick.c usart.c
